options:
  parameters:
    author: sgcderek
    generate_options: qt_gui
    id: fy2_tlm_demod
    output_language: python
    title: FengYun-2 Telemetry Demodulator
  states: {}

blocks:
- name: costas_bw
  id: variable
  parameters:
    comment: |-
      Costas loop
      bandwidth
    value: '0.05'
  states: {}
- name: offset
  id: variable
  parameters:
    comment: |-
      Freq offset of
      the center carrier
    value: '0'
  states: {}
- name: rrc_alpha
  id: variable
  parameters:
    comment: |-
      RRC filter
      alpha
    value: '0.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Sample rate
      of input file
    value: '625000'
  states: {}
- name: sb_rate
  id: variable
  parameters:
    comment: |-
      Sample rate of
      sideband
    value: '10000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: |-
      Symbols per
      sample
      (after resampling
      to sideband rate)
    value: sb_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    comment: Symbol rate
    value: '2000'
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '152588e-10'
    max_gain: '4000'
    rate: '1e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    comment: Lock onto carrier
    max_freq: 2*math.pi*500000/samp_rate
    min_freq: '-2*math.pi*500000/samp_rate'
    w: math.pi/70000
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters:
    comment: |-
      Separate imaginary
      branch
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Binary file output
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Input baseband file
      (SDR# 16-bit wav)
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters:
    comment: |-
      Convert from float
      back to complex
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: |-
      This exists so you can
      disable file sink when
      testing parameters
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    comment: |-
      Shift telemetry carrier
      to center
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '32000'
    comment: Center on data sideband
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"Constellation"'
    size: '200'
    type: complex
    xmax: '0.5'
    xmin: '-0.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Input FFT
    label2: PLL
    name: Input FFT
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: sb_rate
    fc: '0'
    fftsize: '512'
    grid: 'True'
    gui_hint: 0,1,1,1
    legend: 'False'
    name: Sideband
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample to single sideband rate
    decim: samp_rate
    interp: sb_rate
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_alpha
    decim: '1'
    gain: '1'
    ntaps: '101'
    samp_rate: sb_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_1, '0', blocks_throttle_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_imag_1, '0']
- [analog_pll_carriertracking_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_imag_1, '0', blocks_float_to_complex_1, '0']
- [blocks_complex_to_imag_1, '0', blocks_float_to_complex_1, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_complex_1, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_agc_xx_1, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
