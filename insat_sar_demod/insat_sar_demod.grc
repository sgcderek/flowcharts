options:
  parameters:
    author: sgcderek
    generate_options: qt_gui
    id: insat_sar_demod
    output_language: python
    title: INSAT-3 S&R Transponder Demodulator
  states: {}

blocks:
- name: input_rate
  id: variable
  parameters:
    comment: |-
      Sample rate of
      the input baseband
      (should be above 600k)
    value: '1000000'
  states: {}
- name: offset
  id: variable
  parameters:
    comment: |-
      Offset of the S&R
      carrier in the recording
    value: '0'
  states: {}
- name: output_rate
  id: variable
  parameters:
    comment: |-
      Sample rate of
      the output wav file
      (200k default)
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Internal sample
      rate used by the
      flowchart
      (600k default)
    value: '600000'
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.0010e-3'
    reference: '1'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*math.pi*50000/samp_rate
    min_freq: '-2*math.pi*50000/samp_rate'
    w: math.pi/5000
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      16-bit wav input
      (SDR#)
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: input_rate
    type: complex
  states: {state: bypassed}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample4: FORMAT_PCM_16
    comment: |-
      16-bit wav output
      (SDR#)
    format: FORMAT_RF64
    nchan: '2'
    samp_rate: output_rate
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    decim: '1'
    samp_rate: input_rate
    taps: '1'
  states: {}
- name: freq_xlating_fft_filter_ccc_1
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '100000'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: input_rate
    fc: '0'
    fftsize: '16384'
    gui_hint: 0,0,1,1
    legend: 'False'
    name: '"Input FFT"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    gui_hint: 0,1,1,1
    label1: Real
    label2: Imag
    name: '"PLL FFT"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: output_rate
    fc: '0'
    fftsize: '16384'
    gui_hint: 1,0,1,2
    int_max: '-40'
    int_min: '-100'
    name: Output FFT
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: input_rate
    interp: samp_rate
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: output_rate
    type: ccc
  states: {}

connections:
- [analog_agc_xx_0_0, '0', blocks_throttle_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_1, '1']
- [blocks_complex_to_float_0_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_null_sink_0, '1']
- [blocks_complex_to_float_0_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fft_filter_ccc_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_agc_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fft_filter_ccc_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_0_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
