options:
  parameters:
    author: sgcderek
    generate_options: qt_gui
    id: psk_demod
    output_language: python
    title: PSK Demodulator
  states: {}

blocks:
- name: costas_bw
  id: variable
  parameters:
    comment: |-
      Costas loop
      bandwidth
    value: '0.005'
  states: {}
- name: modulation
  id: variable
  parameters:
    comment: |-
      Supported modulations:
      "BPSK"
      "QPSK"
      "8PSK"
      "16QAM"
    value: '"BPSK"'
  states: {}
- name: offset
  id: variable
  parameters:
    comment: |-
      Frequency offset of
      signal center
    value: '0'
  states: {}
- name: rrc_alpha
  id: variable
  parameters:
    comment: |-
      RRC filter alpha
      Examples:
      LRPT/HRPT: ~0.60
      Inmarsat BGAN: ~0.25
    value: '0.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Sample rate of
      baseband file
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: |-
      Samples per
      symbol
      (calculated)
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    comment: |-
      Symbol rate
      of the signal
    value: '100000'
  states: {}
- name: throttle
  id: variable
  parameters:
    comment: |-
      Throttle multiplier
      1 = real time
    value: '1'
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '152588e-10'
    max_gain: '4000'
    rate: '1e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Binary file output
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    comment: |-
      Soft symbols
      file output
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: |-
      This exists so you can
      disable file sink when
      testing parameters
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*throttle
    type: complex
  states: {state: bypassed}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: param.getBits(modulation)
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: param.getConst(modulation)
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: param.getOrder(modulation)
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {state: bypassed}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    comment: |-
      Can be bypassed
      when (offset == 0)
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {state: bypassed}
- name: param
  id: epy_module
  parameters:
    comment: |-
      Python module for
      determining fchart
      parameters
    source_code: |
      import gnuradio

      # PSK order
      def getOrder(modulation):
      	if modulation == "BPSK":
      		order = 2
      	elif modulation == "QPSK":
      		order = 4
      	elif modulation == "8PSK":
      		order = 8
      	elif modulation == "16QAM":
      		order = 4
      	return order
      		
      # Constellation object tnx Xerbo <3
      def getConst(modulation):
      	if modulation == "BPSK":
      		const = gnuradio.digital.constellation_bpsk().base()
      	elif modulation == "QPSK":
      		const = gnuradio.digital.constellation_qpsk().base()
      	elif modulation == "8PSK":
      		const = gnuradio.digital.constellation_8psk().base()
      	elif modulation == "16QAM":
      		const = gnuradio.digital.constellation_16qam().base()
      	return const
      	
      # Bits per symbol
      def getBits(modulation):
      	if modulation == "BPSK":
      		bits = 1
      	elif modulation == "QPSK":
      		bits = 2
      	elif modulation == "8PSK":
      		bits = 3
      	elif modulation == "16QAM":
      		bits = 4
      	return bits
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,2,1
    legend: 'False'
    name: '"Constellation"'
    size: '500'
    type: complex
    xmax: '0.5'
    xmin: '-0.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    color1: '"dark red"'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Amplitude
    legend: 'False'
    name: Input FFT
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Costas
    label2: RRC
    legend: 'False'
    name: Filtered FFT
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    color1: '"dark green"'
    fc: '0'
    fftsize: '32768'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 0,2,1,1
    label1: Amplitude
    legend: 'False'
    name: Cyclo
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rrc_alpha
    decim: '1'
    gain: '1'
    ntaps: '101'
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_1, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_agc_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', digital_costas_loop_cc_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_delay_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0_0, '1']

metadata:
  file_format: 1
